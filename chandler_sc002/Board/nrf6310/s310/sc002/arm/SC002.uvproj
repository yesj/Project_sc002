# Keil uVision project SC002.uvproj, settings and files
target nrf51422_xxaa_s310 (256K) (ARM-ADS)
  device: nRF51422_xxAA Nordic Semiconductor
  cpu: IRAM(0x20002800-0x20003FFF) IROM(0x20000-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: SC002 +hex
  c flags: Optim=1 wLevel=2
  c define: NRF51,DEBUG_NRF_USER,BLE_STACK_SUPPORT_REQD,ANT_STACK_SUPPORT_REQD, BOARD_NRF6310
  c misc: --c99
  c include: ..;..\..\..\..\..\Include;..\..\..\..\..\Include\app_common;..\..\..\..\..\Include\ble;..\..\..\..\..\Include\ble\ble_services;..\..\..\..\..\Include\s310;..\..\..\..\..\Include\sd_common;..\include
  library: MicroLIB
  memory RVCT4: ROM 0x20000 size 0xb000
  memory RVCT9: RAM 0x20002400 size 0x1c00
  group Startup Code
    ./../../../../../Source/templates/arm/: arm_startup_nrf51422_s310.s
    ./../../../../../Source/templates/: system_nrf51.c
  group Source Code
    ../: hrm_tx.c hrm_rx.c
    ./../: main.c
  group Services
    ../../../../../Source/ble/ble_services/: ble_dis.c ble_bas.c ble_cscs.c ble_sc_ctrlpt.c
    ../: ble_nus.c
  group Libraries
    ../../../../../Source/ble/: ble_error_log.c ble_advdata.c ble_conn_params.c ble_bondmngr.c ble_debug_assert_handler.c ble_radio_notification.c ble_flash.c ble_dtm.c ble_sensorsim.c
    ../../../../../Source/ble/ble_services/: ble_srv_common.c
    ../../../../../Source/app_common/: app_timer.c crc16.c pstorage.c app_button.c app_gpiote.c
    ../../../../../Source/sd_common/: softdevice_handler.c
  group SC002Libraries
    ../: ant_csc_tx.c battery.c csc_services.c nus_service.c dtm_rf_test.c
